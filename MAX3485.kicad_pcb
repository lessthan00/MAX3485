# Repository lessthan00/MAX3485

File README.md:

# MAX3485

[MAX3485](https://www.jlc-smt.com/lcsc/detail?componentCode=C668204)  
半双工  
12Mbps  
RS485/422收发器

## KiCad design MAX3485.kicad_pcb

Parts:
C1: 100nF; C_1206_3216Metric
C2: 1nF; C_1206_3216Metric
D1: 1N4148W; D_SOD-123
J1: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J2: JST_04; TerminalBlock_Phoenix_MKDS-3-4-5.08_1x04_P5.08mm_Horizontal
J3: Conn_01x05; PinHeader_1x05_P2.54mm_Vertical
Q1: SS8050; SOT-23
R1, R2, R3, R5, R7: 10K; R_1206_3216Metric
R4: 1K; R_1206_3216Metric
R6: 120R; R_1206_3216Metric
U1: MAX3485; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+3.3V: C1.1, J1.2, J2.4, J3.1, R1.1, R2.1, R4.1, R5.1, U1.8 (VCC)
/EN: D1.1 (K), J1.1, J3.5, R3.1
/RS485_EN: Q1.3 (C), R4.2, U1.2 (~RE), U1.3 (DE)
/RS-485-A: J2.3, R5.2, R6.1, U1.6 (A)
/RS-485-B: J2.2, R6.2, R7.1, U1.7 (B)
/USART_RX: J3.3, R2.2, U1.1 (RO)
/USART_TX: J3.2, R1.2, U1.4 (DI)
GND: C1.2, C2.2, J2.1, J3.4, Q1.2 (E), R7.2, U1.5 (GND)
unnamed: C2.1, D1.2 (A), Q1.1 (B), R3.2

Notes on the sheet:
添加地线抑制共模干扰 添加120R终端电阻支持长距离通讯 添加备用电源线.

Board: 2 copper layers, 41.0 x 25.0 mm, 15 parts (0 on the bottom side), 9 nets.
